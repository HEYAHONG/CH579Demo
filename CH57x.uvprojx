# Keil uVision project CH57x.uvprojx, settings and files
target CH57x (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: CH579F WCH
  pack: Keil.WCH57x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CH57x +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: DEBUG=Debug_UART1
  c include: .\lib\CH579EVT\EVT\EXAM\SRC\CMSIS\Include;.\lib\CH579EVT\EVT\EXAM\SRC\Startup;.\lib\CH579EVT\EVT\EXAM\SRC\StdPeriphDriver\inc;.\lib\FreeRTOS;.\lib\FreeRTOS\FreeRTOS-Kernel\include;.\lib\FreeRTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM0;.\lib\lwip;.\lib\lwip\lwip\src\include;.\lib\lwip\lwip\contrib\ports\freertos\include;.\lib\lwip\lwip\src\include\compat\posix;.\lib\lwip\lwip\src\include\compat\stdc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20004000 size 0x4000
  group user
    ./: Main.c
  group peripheral
    ./lib/CH579EVT/EVT/EXAM/SRC/StdPeriphDriver/: CH57x_adc.c CH57x_clk.c CH57x_flash.c CH57x_gpio.c CH57x_int.c CH57x_lcd.c CH57x_pwm.c CH57x_pwr.c CH57x_spi0.c CH57x_spi1.c CH57x_sys.c CH57x_timer0.c CH57x_timer1.c CH57x_timer2.c CH57x_timer3.c CH57x_uart0.c CH57x_uart1.c CH57x_uart2.c CH57x_uart3.c CH57x_usbdev.c
  group startup
    ./lib/CH579EVT/EVT/EXAM/SRC/Startup/: startup_ARMCM0.s
  group FreeRTOS
    ./lib/FreeRTOS/: FreeRTOSPort.c FreeRTOSConfig.h FreeRTOSPort.h
    ./lib/FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./lib/FreeRTOS/FreeRTOS-Kernel/portable/RVDS/ARM_CM0/: port.c
    ./lib/FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group LWIP
    ./lib/lwip/lwip/contrib/ports/freertos/: sys_arch.c
    ./lib/lwip/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./lib/lwip/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./lib/lwip/lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ./lib/lwip/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ./lib/lwip/lwip/src/netif/: ethernet.c bridgeif.c bridgeif_fdb.c lowpan6.c lowpan6_ble.c lowpan6_common.c
    ./lib/lwip/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
    ./lib/lwip/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ./lib/lwip/: lwipopts.h lwipport.c ETH.c ETH.h
    ./lib/lwip/arch/: cc.h
